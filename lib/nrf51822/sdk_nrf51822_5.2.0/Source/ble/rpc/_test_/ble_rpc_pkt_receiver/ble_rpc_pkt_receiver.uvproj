# Keil uVision project ble_rpc_pkt_receiver.uvproj, settings and files
target toxophilite (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: cunit_test
  c flags: Optim=1
  c define: NRF51, NRF51822_QFAA_CA, BOARD_NRF6310, SVCALL_AS_NORMAL_FUNCTION
  c misc: --diag_suppress 177 --diag_suppress 170 --c99
  c include: ..\..\..\..\..\..\..\framework\cunit\keil_include_overwrite;..\..\..\..\..\Include;..\..\..\..\..\..\..\framework\cunit;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\ble\rpc;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\sd_common;..\..\..\..\..\Include\app_common\mock;..\..\..\..\..\Include\stm
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x20004000
  link misc: --remove
  group Testbench
    ./: cunit_test.c
  group core
    ../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ../../../../../../../framework/cunit/: system_nrf51.c
  group module
    ../../: ble_rpc_pkt_receiver.c
  group framework
    ../../../../../../../framework/cunit/: uart.c nrf_cunit.c nrf_cunit_mock.c
    ../../../../app_common/mock/hci_transport/: hci_transport_mock.c
    ../../mock/: ble_rpc_cmd_encoder_mock.c ble_rpc_evt_decoder_mock.c
    ../../../test/mock/: ble_stack_handler_mock.c
    ../../../../app_common/mock/app_scheduler/: app_scheduler_mock.c
